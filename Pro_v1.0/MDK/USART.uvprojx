# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\mcu\common;..\source;..\driver\inc;..\hardware\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ../mcu/common/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: hc32f460_utility.c hc32f460_sram.c hc32f460_icg.c hc32f460_gpio.c hc32f460_exint_nmi_swi.c hc32f460_clk.c hc32f460_efm.c hc32f460_interrupts.c hc32f460_pwc.c hc32f460_usart.c
  group Readme
    ../: Readme.txt
  group hardware
    ../hardware/: led.c usart.c key.c
software components: CMSIS:CORE 5.6.0
